# Keil uVision project 74hc595_led.uvprojx, settings and files
target 74hc595_led (6150000::V6.15::ARMCLANG)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 74hc595_led
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\User\Inc;..\Firmware\CMSIS\GD\GD32F1x0\Include;..\Firmware\GD32F1x0_standard_peripheral\Include;..\Utilities;..\Firmware\GD32F1x0_usbd_library\usbd\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/Src/: gd32f1x0_it.c main.c systick.c usart.c 74hc595_led.c function.c encoder.c timer.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ./: startup_gd32f1x0.s
  group Library
    ../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Utilities
    ../Utilities/: gd32f1x0r_eval.c
  group Docs
    ../Docs/: readme.md gpio分配.md
software components: CMSIS:CORE 5.5.0
